<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Master_SPI\master_spi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SPI_Slave.ewp</path>
    </project>
    <batchBuild />
</workspace>
