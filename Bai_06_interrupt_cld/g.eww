<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Bai_01_hienthiecl.ewp</path>
    </project>
    <batchBuild />
</workspace>
